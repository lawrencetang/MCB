# Keil uVision project KOSPE-CTRL-V2.0.uvproj, settings and files
target KOSPE-CTRL-V2 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KOSPE-CTRL-V2-20180206 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Source\AppDriver\inc;.\Source\Application\inc;.\Source\stm32f10xDriver\inc;.\Source\uCOS-II\Source;.\Source\uCOS-II\Ports;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\usbDriver\usb_inc;.\Source\usbDriver\STM32_USB-FS-Device_Driver\sys_inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./Source/Application/src/: main.c task.c
  group AppDriver
    ./Source/AppDriver/src/: dcMotor.c bsp.c frame.c nvic.c queue.c stm32f10x_it.c timer2.c system_stm32f10x.c common.c pcComm.c stepMotor.c timer3.c timer5.c temControl.c temDriver.c adcDriver.c eeprom.c spi1.c absEncoder.c spi2.c uart1.c encrypt.c
  group uCOS-II
    ./Source/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
    ./Source/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
    ./Source/uCOS-II/uC-CPU/: cpu_def.h cpu.h
  group usbDriver
    ./Source/usbDriver/usb_src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ./Source/usbDriver/STM32_USB-FS-Device_Driver/sys_src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group stm32f10xDriver
    ./Source/stm32f10xDriver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c
  group StartUp
    ./Source/StartUp/: stm32f10x_startup.s cortexm3_macro.s
  group 文档
    ./Source/文档/: 修改记录.txt
